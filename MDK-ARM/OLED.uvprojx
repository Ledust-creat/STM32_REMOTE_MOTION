# Keil uVision project OLED.uvprojx, settings and files
target OLED (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Components/OLED;../Components/SHT30;../Components/RCWL0515;../Components/ML307C;../BSP/UART;../APP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Components/OLED
    ../Components/OLED/: OLED.c OLED.h OLED_Font.h OLED_Port.h
  group Components/SHT30
    ../Components/SHT30/: SHT30.c SHT30.h SHT30_Port.h
  group Components/RCWL0515
    ../Components/RCWL0515/: RCWL0515.c RCWL0515.h RCWL0515_Port.h
  group Components/ML307C
    ../Components/ML307C/: ML307C.c ML307C.h ML307C_Port.h ML307C_Config.h
  group BSP/I2C
    ../BSP/I2C/: OLED_Port_stm32_hal.c SHT30_Port_stm32_hal.c
  group BSP/UART
    ../BSP/UART/: BSP_UART.c BSP_UART.h ML307C_Port_stm32_hal.c
  group BSP/GPIO
    ../BSP/GPIO/: RCWL0515_Port_stm32_hal.c
  group BSP/RTC
    ../BSP/RTC/: App_Monitor_Port_stm32_hal.c
  group APP
    ../APP/: App_Monitor.c App_Monitor.h App_Monitor_Config.h App_Monitor_Port.h
software components: CMSIS:CORE 4.3.0
